## boards/shields/macr03xDpcb/Kconfig.defconfig
```kconfig
if SHIELD_MACR03XDPCB

config ZMK_KEYBOARD_NAME 
    default "macr03xD_pcb"

endif
```
